** sch_path: testbenches/xschem/sparx_top_tb_tran_ngspice.sch
* SPDX-FileCopyrightText: 2025-2026 The SPARX Team
* SPDX-License-Identifier: Apache-2.0 WITH SHL-2.1
**.subckt sparx_top_tb_tran_ngspice
vlo vlo GND sin(0 1 159G)
vrf vrf GND sin(0 200m 161G)
x1 vout2 vout1 VDD GND vref1 vref2 vrf vlo vout4 vref4 vref3 vout3 sparx_top
VDD VDD GND 1.5
C1 vout1 GND 2p m=1
C2 vout2 GND 2p m=1
C3 vout3 GND 2p m=1
C4 vout4 GND 2p m=1
**** begin user architecture code


.include ../../../netlist/spice/sparx_bpf_le.spice
.include ../../../netlist/spice/sparx_wpd_le.spice
.include ../../../netlist/spice/sparx_blc_le.spice
.include ../sim_range.spice
.temp 27
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-15 gmin=1e-15
.control

save all

set wr_vecnames
set wr_singlescale

* User Constants
* f_min / f_max come from ../sim_range.spice (.csparam),
* auto-synced to the loaded Touchstone by snp2le.
* edit that file for a standalone run.

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
tran 1n 15n
remzerovec
write @schname\.raw
set appendwrite

* Plotting
plot vref1 vref2 vref3 vref4
plot vout1 vout2 vout3 vout4

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/@schname\.txt  vref1 vref2 vref3 vref4  vout1 vout2 vout3 vout4

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
