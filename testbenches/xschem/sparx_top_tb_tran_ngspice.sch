** sch_path: testbenches/xschem/sparx_top_tb_tran_ngspice.sch
* SPDX-FileCopyrightText: 2025-2026 The SPARX Team
* SPDX-License-Identifier: Apache-2.0 WITH SHL-2.1
**.subckt sparx_top_tb_tran_ngspice
vlo lo_src GND sin(0 2.52 159G)
Rlo vlo lo_src 50 m=1
Rrf vrf rf_src 50 m=1
vrf rf_src GND sin(0 63.2m 161G)
x1 vout2 vout1 VDD GND vref1 vref2 vrf vlo vout4 vref4 vref3 vout3 sparx_top
VDD VDD GND 1.5
C1 vout1 GND 5p m=1
C2 vout2 GND 5p m=1
C3 vout3 GND 5p m=1
C4 vout4 GND 5p m=1
C5 vref1 GND 5p m=1
C6 vref2 GND 5p m=1
C7 vref3 GND 5p m=1
C8 vref4 GND 5p m=1
**** begin user architecture code


.include ../../../netlist/spice/sparx_bpf_le.spice
.include ../../../netlist/spice/sparx_wpd_le.spice
.include ../../../netlist/spice/sparx_blc_le.spice
.include ../sim_range.spice
.temp 27
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-15 gmin=1e-15 interp
.control

save all

set wr_vecnames
set wr_singlescale

* User Constants
* LO +12 dBm and RF -20 dBm available at the pads: both sources sit behind 50 Ohm,
* so a source amplitude a is an available power a^2 / (8 * 50), 2.52 V and 63.2 mV.
* +12 dBm at the LO pad puts about -6.5 dBm on each detector behind the 16 to 18 dB
* of the LO path, the operating point of the detector benches.
* 3 ns of transient with the integrator step capped at 20 fs (tmax): the LTE control alone
* lets Gear take 0.3 ps steps on the 161 GHz carrier and damps it, the IF outputs then
* come out 12 times too small. interp writes the output on the 1 ps grid of tstep, without it
* every accepted step of the 161 GHz carrier lands in the rawfile (500 MB for 15 ns).
* f_min / f_max come from ../sim_range.spice (.csparam),
* auto-synced to the loaded Touchstone by snp2le.
* edit that file for a standalone run.

* Operating Point Analysis
op
remzerovec
write @schname\.raw
set appendwrite

* Transient Analysis
tran 1p 3n 0 20f
remzerovec
write @schname\.raw
set appendwrite

* Plotting
plot vref1 vref2 vref3 vref4
plot vout1 vout2 vout3 vout4

* Write Data
unset appendwrite
set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/@schname\.txt  vref1 vref2 vref3 vref4  vout1 vout2 vout3 vout4

*quit
.endc



.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerHBT.lib hbt_typ
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ
.lib cornerDIO.lib dio_tt


.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.GLOBAL VDD
.end
