** sch_path: testbenches/xschem/sparx_powdet_sbd_tb_acsp_ngspice.sch
* SPDX-FileCopyrightText: 2025-2026 The SPARX Team
* SPDX-License-Identifier: Apache-2.0 WITH SHL-2.1
* (c) 2026 H. Pretl, ICD@JKU
**.subckt sparx_powdet_sbd_tb_acsp_ngspice
Vss gnd_local GND 0
Vin3 rfin gnd_local dc 0 ac 0 portnum 1 z0 50
Vin1 rfdummy GND dc 0 ac 0 portnum 2
C3 rfdummy GND 1f m=1
.save v(rfin)
.save v(out_cm)
Vdd vdd gnd_local 1.5
.save v(ref)
C1 out_cm gnd_local 5p m=1
C2 ref gnd_local 5p m=1
x1 out_cm ref vdd rfin gnd_local sparx_powdet_sbd
**** begin user architecture code

.lib cornerDIO.lib dio_tt
.lib cornerMOSlv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ



.temp 27
.save all
.options savecurrents klu method=gear reltol=1e-3 abstol=1e-12 gmin=1e-12 rshunt=1e14
.control
set num_threads=8
* z0 of the RF port Vin3, the reference of S11
let z0 = 50

op
write @schname\.raw

* write fails after sp, which has none of the device currents savecurrents
* asks for, so the sp vectors are exported with wrdata only
sp lin 101 100G 200G 0

let s11_dB = db(S_1_1)
let s11_deg = cph(S_1_1) * 180/pi
let zin_re = real(z0 * (1 + S_1_1) / (1 - S_1_1))
let zin_im = imag(z0 * (1 + S_1_1) / (1 - S_1_1))
meas sp s11_dB_160G FIND s11_dB AT=160e9
meas sp zin_re_160G FIND zin_re AT=160e9
meas sp zin_im_160G FIND zin_im AT=160e9
plot s11_dB
plot zin_re zin_im

set wr_vecnames
set wr_singlescale
wrdata ../plot_simulations/data/@schname\.txt  s11_dB s11_deg zin_re zin_im
.endc



.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.end
