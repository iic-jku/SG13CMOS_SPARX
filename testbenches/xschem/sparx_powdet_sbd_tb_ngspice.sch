** sch_path: testbenches/xschem/sparx_powdet_sbd_tb_ngspice.sch
* SPDX-FileCopyrightText: 2025-2026 The SPARX Team
* SPDX-License-Identifier: Apache-2.0 WITH SHL-2.1
* (c) 2026 H. Pretl, ICD@JKU
**.subckt sparx_powdet_sbd_tb_ngspice
Vss gnd_local GND 0
Vin3 rfin net1 dc 0 ac 0 portnum 1 z0 50 sin(0 {rf_lev} {rf_freq})
.save v(rfin)
.save v(out_cm)
Vin2 net1 gnd_local dc 0 ac 0 sin(0 {lo_lev} {lo_freq})
Vdd vdd gnd_local 1.5
.save v(ref)
C1 out_cm gnd_local 5p m=1
C2 ref gnd_local 5p m=1
E1 out gnd_local out_cm ref 1
.save v(out)
* noconn out
x1 out_cm ref vdd rfin gnd_local sparx_powdet_sbd
**** begin user architecture code

.lib cornerDIO.lib dio_tt
.lib cornerMOSlv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ



.temp 27
.save all
.param lo_freq=159G
.param lo_lev=300m
.param rf_freq=161G
.param rf_lev=3m
* no klu: on the extracted netlist (VARIANT=m1_pex) KLU finds the operating
* point only by its transient fallback and aborts the transient at 0.1 ps
.options savecurrents method=gear reltol=1e-3 abstol=1e-12 gmin=1e-12 rshunt=1e14
.control
set num_threads=8
*set specwindow=blackman

let lo_freq = 159G
let rf_freq = 161G
let if_freq = rf_freq - lo_freq

op
write @schname\.raw
set appendwrite

tran 0.05p 22n 20n
write @schname\.raw

* tone amplitudes by Fourier projection over the 2 ns window, a whole number
* of LO, RF and IF periods (meas FIND on an fft would read the real part)
linearize rfin out
setplot tran2
let c = mean(rfin*cos(2*pi*lo_freq*time))
let s = mean(rfin*sin(2*pi*lo_freq*time))
let lo_amp = 2*sqrt(c*c + s*s)
let c = mean(rfin*cos(2*pi*rf_freq*time))
let s = mean(rfin*sin(2*pi*rf_freq*time))
let rf_amp = 2*sqrt(c*c + s*s)
let c = mean(out*cos(2*pi*if_freq*time))
let s = mean(out*sin(2*pi*if_freq*time))
let if_amp = 2*sqrt(c*c + s*s)
print lo_amp > result.txt
print rf_amp >> result.txt
print if_amp >> result.txt
fft rfin
plot db(rfin)
setplot tran2
fft out
plot db(out)

*exit
.endc



.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.end
