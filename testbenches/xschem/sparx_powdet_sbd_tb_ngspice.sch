** sch_path: testbenches/xschem/sparx_powdet_sbd_tb_ngspice.sch
* SPDX-FileCopyrightText: 2025-2026 The SPARX Team
* SPDX-License-Identifier: Apache-2.0 WITH SHL-2.1
* (c) 2026 H. Pretl, ICD@JKU
**.subckt sparx_powdet_sbd_tb_ngspice
Vss gnd_local GND 0
Vin3 rfin net1 dc 0 ac 0 portnum 1 z0 50 sin(0 {rf_lev} {rf_freq})
Vin1 rfdummy GND dc 0 ac 0 portnum 2
C3 rfdummy GND 1f m=1
.save v(rfin)
.save v(out_cm)
Vin2 net1 gnd_local dc 0 ac 0 sin(0 {lo_lev} {lo_freq})
Vdd vdd gnd_local 1.5
.save v(ref)
C1 out_cm gnd_local 5p m=1
C2 ref gnd_local 5p m=1
E1 out gnd_local out_cm ref 1
.save v(out)
* noconn out
x1 out_cm ref vdd rfin gnd_local sparx_powdet_sbd
**** begin user architecture code

.lib cornerDIO.lib dio_tt
.lib cornerMOSlv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerCAP.lib cap_typ



.temp 27
.save all
.param lo_freq=159G
.param lo_lev=300m
.param rf_freq=161G
.param rf_lev=3m
* no klu: on the extracted netlist (VARIANT=m1_pex) KLU finds the operating
* point only by its transient fallback and aborts the transient at 0.1 ps
.options savecurrents method=gear reltol=1e-3 abstol=1e-12 gmin=1e-12 rshunt=1e14
.control
set num_threads=8
*set specwindow=blackman

let lo_freq = 159G
let rf_freq = 161G
let if_freq = rf_freq - lo_freq

op
write @schname\.raw
set appendwrite

sp lin 31 100G 200G 0
write @schname\.raw

ac dec 1001 1MEG 10G
write @schname\.raw

tran 0.05p 22n 20n
write @schname\.raw

linearize rfin out
setplot tran2
fft rfin
plot db(rfin)
meas sp lo_tone FIND v(rfin) AT=$&lo_freq
meas sp rf_tone FIND v(rfin) AT=$&rf_freq
print lo_tone > result.txt
print rf_tone >> result.txt
setplot tran2
fft out
plot db(out)
meas sp if_tone FIND v(out) AT=$&if_freq
print if_tone >> result.txt

*exit
.endc



.include [file rootname [file tail [xschem get schname]]].save

**** end user architecture code
**.ends
.GLOBAL GND
.end
